Commit message: 2026 0826-MPC依赖环境本地部署和包名迁移

File: src/myrobot_support_ws/fairino_description/urdf/fairino3_v6.urdf (robot description, URDF)
Before this commit: robot fairino3_v6_robot, 9 links, 8 joints
Joints:
- joint tool0_fixed_joint: origin xyz=0 0 0.2168 rpy=0 0 0 -> xyz=0 0 0.11 rpy=0 0 0
